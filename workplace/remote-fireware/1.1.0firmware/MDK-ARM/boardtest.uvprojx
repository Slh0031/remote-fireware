# Keil uVision project boardtest.uvprojx, settings and files
target boardtest (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: boardtest +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../bsp/inc;../application/inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../application/src/U8G2
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group bsp
    ../bsp/src/: oled_iic.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group app
    ../application/src/: Task_led.c Task_buzzer.c Task_Date_pack.c Task_adc.c ic_rgb.c oled_menu.c Task_key.c
    ../application/inc/: includes.h gift.h
  group u8g2
    ../application/src/U8G2/: mui_u8g2.c u8g2_d_memory.c mui.c u8g2_button.c mui.h u8g2_circle.c mui_u8g2.h u8g2_box.c u8g2_buffer.c u8g2.h u8g2_input_value.c u8g2_bitmap.c u8g2_intersection.c u8g2_kerning.c u8g2_cleardisplay.c u8x8_display.c u8g2_ll_hvline.c u8g2_fonts.c u8x8_input_value.c u8g2_d_setup.c u8log_u8x8.c u8g2_font.c u8g2_hvline.c u8x8_debounce.c u8g2_polygon.c u8g2_line.c u8g2_message.c u8x8_d_ssd1306_128x64_noname.c u8x8_8x8.c u8g2_setup.c u8log.c u8x8_message.c u8g2_selection_list.c u8x8_byte.c u8log_u8g2.c u8x8.h u8x8_cad.c u8x8_capture.c u8x8_gpio.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_fonts.c u8x8_u8toa.c u8x8_u16toa.c
software components: CMSIS:CORE 4.3.0
